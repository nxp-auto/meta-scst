FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRC_URI += " \
	file://0001-add-atf-scst-runtime-service.patch \	
	"
