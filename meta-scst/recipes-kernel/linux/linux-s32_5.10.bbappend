FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"
SRC_URI += " \
	file://0001-add-dts-scst-reserved-memory.patch \
"

